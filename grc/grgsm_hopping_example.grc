options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: grgsm_hopping_example
    output_language: python
    run_options: run
  states: {}

blocks:
- name: a5_version
  id: variable_function_probe
  parameters:
    block_id: gsm_extract_cmc_0
    function_name: get_a5_versions
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: A5 versions
    type: int
    value: a5_version
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /root/out_110.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: /root/out_118.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: ''
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: ''
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: fc
  id: parameter
  parameters:
    label: fc
    short_id: f
    type: eng_float
    value: 957e6
  states: {}
- name: gsm_burst_file_sink_0
  id: gsm_burst_file_sink
  parameters:
    filename: /root/bursts
  states: {state: disabled}
- name: gsm_bursts_printer_0
  id: gsm_bursts_printer
  parameters:
    ignore_dummy_bursts: 'False'
    prepend_fnr: 'True'
    prepend_frame_count: 'True'
    print_payload_only: 'True'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0_0_0_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_cx_channel_hopper_0
  id: gsm_cx_channel_hopper
  parameters:
    hsn: '51'
    ma: '[110,118]'
    maio: '0'
  states: {}
- name: gsm_extract_cmc_0
  id: gsm_extract_cmc
  parameters: {}
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_input_0_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'True'
    prepend_frame_count: 'True'
    prepend_string: '""'
    print_gsmtap_header: 'True'
  states: {state: disabled}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[110,118]'
    num_streams: '2'
    osr: osr
    tseq_nums: '[5]'
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '3'
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: clock_correction
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: 1e6
  states: {}

connections:
- [blocks_file_source_0, '0', gsm_input_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0_2, '0', gsm_input_0_0, '0']
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0_0, ctrl_in]
- [gsm_control_channels_decoder_0_0_0_0_0_0, msgs, blocks_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0_0_0_0_0, msgs, gsm_bursts_printer_0, bursts]
- [gsm_control_channels_decoder_0_0_0_0_0_0, msgs, gsm_extract_cmc_0, msgs]
- [gsm_control_channels_decoder_0_0_0_0_0_0, msgs, gsm_message_printer_0, msgs]
- [gsm_cx_channel_hopper_0, bursts, gsm_sdcch8_demapper_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_input_0_0, '0', gsm_receiver_0, '1']
- [gsm_receiver_0, C0, gsm_burst_file_sink_0, in]
- [gsm_receiver_0, C0, gsm_cx_channel_hopper_0, CX]
- [gsm_receiver_0, CX, gsm_burst_file_sink_0, in]
- [gsm_receiver_0, CX, gsm_cx_channel_hopper_0, CX]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_control_channels_decoder_0_0_0_0_0_0, bursts]

metadata:
  file_format: 1
